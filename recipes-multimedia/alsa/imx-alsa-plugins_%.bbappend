COMPATIBLE_MACHINE = "(udooneo|udooqdl|secosbca62)"
