RDEPENDS_${PN}_remove = "\
    nativesdk-cmake \
"
